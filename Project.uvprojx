# Keil uVision project Project.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Project
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_HD
  c include: .\User;.\PLC;.\Driver;.\STM32F10x_StdPeriph_Driver\inc;.\CORE;.\USB\STM32_USB-FS-Device_Driver\inc;.\USB\CONFIG
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group User
    ./User/: main.c sys.c stm32f10x_it.c system_stm32f10x.c
    ./CORE/: startup_stm32f10x_hd.s
  group Driver
    ./Driver/: DAC.C i2c.c IRQ.c ADC.C
  group PLC
    ./PLC/: CLK.c Ladder.c usart_com.c BSP.c
  group ST_LIB
    ./STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_crc.c stm32f10x_cec.c stm32f10x_dac.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_spi.c stm32f10x_usart.c stm32f10x_tim.c stm32f10x_rcc.c
  group Core
    ./CORE/: core_cm3.c
  group USB_CORE
    ./USB/STM32_USB-FS-Device_Driver/src/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c usb_sil.c
  group USB_CONFIG
    ./USB/CONFIG/: hw_config.c usb_desc.c usb_endp.c usb_istr.c usb_prop.c usb_pwr.c
